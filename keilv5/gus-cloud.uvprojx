# Keil uVision project gus-cloud.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gus-cloud
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,MGR_TASK_ENABLE
  c include: ..\src\library\CMSIS\CM3\CoreSupport;..\src\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\library\STM32F10x_StdPeriph_Driver\inc;..\src\library\STM32F10x_StdPeriph_Driver\it;..\src\freertos\include;..\src\freertos\portable\RVDS\ARM_CM3;..\src\hal;..\src\user;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../src/library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group cmsis
    ../src/library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib
    ../src/library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal
    ../src/hal/led/: led.c
    ../src/hal/usart/: usart.c
    ../src/hal/time/: time.c
    ../src/hal/crc/: crc16.c
    ../src/hal/spi/: spi.c
  group freertos
    ../src/freertos/: tasks.c list.c queue.c
    ../src/freertos/portable/RVDS/ARM_CM3/: port.c
    ../src/freertos/portable/MemMang/: heap_4.c
  group cJSON
    ../src/cJSON/: cJSON.c cJSON_test.c
  group it
    ../src/library/STM32F10x_StdPeriph_Driver/it/: stm32f10x_it.c
  group user
    ../src/user/: main.c
  group readme
    ../src/: readme.txt
software components: CMSIS:CORE 5.0.1
